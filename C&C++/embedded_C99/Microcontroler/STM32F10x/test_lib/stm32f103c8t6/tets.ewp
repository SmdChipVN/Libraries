# IAR project tets.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\IC\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Module\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Protocol\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Sensor\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\0_Common\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\1_Application\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\2_SoftPeripheral\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\3_Middleware\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\4_Math\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\5_Algorithm\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\STM32F10x\drive\0_include; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\STM32F10x; C:\Users\jfavl\OneDrive\Libraries\C&C++\embedded_C99\Microcontroler\STM32F10x\test_lib\stm32f103c8t6\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tets.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../../1_Application/button/: button_0.c button_1.c button_2.c button_3.c button_4.c button_5.c button_6.c button_7.c
    source/: main.c
